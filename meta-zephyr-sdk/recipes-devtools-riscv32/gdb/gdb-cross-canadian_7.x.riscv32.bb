require recipes-devtools/gdb/gdb-common.inc
require recipes-devtools/gdb/gdb-cross-canadian.inc
require recipes-devtools-riscv32/gdb/gdb-7.x.riscv32.inc
