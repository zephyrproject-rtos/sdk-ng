require recipes-devtools-riscv32/gcc/gcc-6.x.riscv32.inc
require recipes-devtools/gcc/gcc-source.inc
