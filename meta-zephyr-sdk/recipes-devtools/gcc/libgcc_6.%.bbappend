EXTRA_OECONF_remove_arm =   "--disable_multilib"
EXTRA_OECONF_append_arm =   " --enable-multilib"
EXTRA_OECONF_remove_x86 =   "--disable_multilib"
EXTRA_OECONF_append_x86 =   " --enable-multilib"
EXTRA_OECONF_remove_arc =   "--disable_multilib"
EXTRA_OECONF_append_arc =   " --enable-multilib"
EXTRA_OECONF_remove_nios2 = "--disable_multilib"
EXTRA_OECONF_append_nios2 = " --enable-multilib"


