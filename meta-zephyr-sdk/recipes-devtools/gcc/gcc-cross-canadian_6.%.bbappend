
EXTRA_OECONF_append = " --with-gnu-as "
EXTRA_OECONF_append_libc-baremetal = " --enable-plugin"
