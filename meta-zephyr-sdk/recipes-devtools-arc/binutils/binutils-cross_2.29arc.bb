require recipes-devtools/binutils/binutils.inc
require binutils-2.29arc.inc
require recipes-devtools/binutils/binutils-cross.inc

COMPATIBLE_MACHINE = "arc"
